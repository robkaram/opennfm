# IAR project onfm.ewp, settings and files
configuration Debug (ARM, debug)
  General.RTConfigPath: $TOOLKIT_DIR$\INC\DLib_Config_Normal.h
  General.OGChipSelectEditMenu: LPC3131 NXP LPC3131
  ICCARM.CCIncludePath2: ..\..; ..\..\sys\lpc313x\bsp; ..\..\sys\lpc313x\csp; ..\..\sys\lpc313x\lib; ..\..\sys\lpc313x\usb
  ICCARM.CCStdIncludePath: $TOOLKIT_DIR$\INC\
  ICCARM.CCOptLevel: 0
  ICCARM.CCOptStrategy: 0
  OBJCOPY.OOCOutputFile: onfm.srec
  ILINK.IlinkOutputFile: onfm.out
  ILINK.IlinkIcfFile: ..\..\sys\lpc313x\config\LPC313x_iRAM.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration Release (ARM)
  as the first configuration, except:
  ICCARM.CCDefines: NDEBUG
  ICCARM.CCOptLevel: 3
  ICCARM.CCOptStrategy: 2
  group core
    ../../: cfg.h
    ../../core/: onfm.c
  group core/buf
    ../../core/buf/: buf_api.c
  group core/ftl
    ../../core/ftl/: ftl_api.c ftl_bdt.c ftl_data.c ftl_hdi.c ftl_inc.h ftl_pmt.c ftl_root.c
  group core/mtd
    ../../core/mtd/: mtd_api.c
  group core/ubi
    ../../core/ubi/: ubi_anchor.c ubi_api.c ubi_area.c ubi_inc.h ubi_index.c ubi_table.c
  group lpc313x
    ../../sys/lpc313x/: main.c
  group lpc313x/bsp
    ../../sys/lpc313x/bsp/: arm926ej_cp15_drv.c cstartup.s spinor_bootloader.c vectors.s
  group lpc313x/csp
    ../../sys/lpc313x/csp/: drv_cgu.c drv_intc.c drv_nand.c drv_spi.c drv_spinor.c drv_uart.c
  group lpc313x/lib
    ../../sys/lpc313x/lib/: lpc313x_cgu_driver.c lpc313x_timer_driver.c lpc313x_usbdcd.c
  group lpc313x/usb
    ../../sys/lpc313x/usb/: mscuser.c usbcore.c usbdesc.c
